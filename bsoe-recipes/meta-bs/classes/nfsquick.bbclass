# Minimal nfsquick class stub
# This appears to be a BrightSign-specific class for NFS deployment
# Creating empty stub to allow parsing to continue

python () {
    bb.debug(1, "nfsquick class loaded (stub)")
}